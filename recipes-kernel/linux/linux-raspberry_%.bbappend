FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://9670.cfg"